# Keil uVision project W5100S_EVB_FW_STM32.uvprojx, settings and files
target W5100S_EVB_FW_STM32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: W5500_EVB_FW_STM32 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F411xE MBEDTLS_CONFIG_FILE=<ssl_config.h>,STM32F411xE
  c include: ../Core/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;  ../Drivers/CMSIS/Include;  ..\libraries\ioLibrary_Driver\Ethernet;  ..\libraries\ioLibrary_Driver\Ethernet\W5100S;  ..\libraries\ioLibrary_Driver\Internet\DHCP;  ..\libraries\ioLibrary_Driver\Internet\DNS;  ..\libraries\ioLibrary_Driver\Internet\FTPClient;  ..\libraries\ioLibrary_Driver\Internet\FTPServer;  ..\libraries\ioLibrary_Driver\Internet\httpServer;  ..\libraries\ioLibrary_Driver\Internet\MQTT;  ..\libraries\ioLibrary_Driver\Internet\MQTT\MQTTPacket\src;  ..\libraries\ioLibrary_Driver\Internet\SNMP;  ..\libraries\ioLibrary_Driver\Internet\SNTP;  ..\libraries\ioLibrary_Driver\Internet\TFTP;  ..\libraries\mbedtls\include;  ..\port\ioLibrary_Driver;  ..\port\mbedtls\inc;  ..\port\timer;  ..\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group ioLibrary_Driver
    ../libraries/ioLibrary_Driver/Ethernet/W5100S/: w5100s.c
    ../libraries/ioLibrary_Driver/Ethernet/: socket.c wizchip_conf.c
    ../libraries/ioLibrary_Driver/Internet/DHCP/: dhcp.c
    ../libraries/ioLibrary_Driver/Internet/DNS/: dns.c
    ../libraries/ioLibrary_Driver/Internet/FTPClient/: ftpc.c
    ../libraries/ioLibrary_Driver/Internet/FTPServer/: ftpd.c
    ../libraries/ioLibrary_Driver/Internet/httpServer/: httpParser.c httpServer.c httpUtil.c
    ../libraries/ioLibrary_Driver/Internet/MQTT/: mqtt_interface.c MQTTClient.c
    ../libraries/ioLibrary_Driver/Internet/MQTT/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ../libraries/ioLibrary_Driver/Internet/SNMP/: snmp_custom.c snmp.c
    ../libraries/ioLibrary_Driver/Internet/SNTP/: sntp.c
    ../libraries/ioLibrary_Driver/Internet/TFTP/: netutil.c tftp.c
    ../libraries/ioLibrary_Driver/Ethernet/W5100/: w5100.c
    ../libraries/ioLibrary_Driver/Ethernet/W5200/: w5200.c
    ../libraries/ioLibrary_Driver/Ethernet/W5300/: w5300.c
    ../libraries/ioLibrary_Driver/Ethernet/W5500/: w5500.c
  group mbedtls
    ../libraries/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_driver_wrappers.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group port
    ../port/ioLibrary_Driver/: w5x00_spi.c
    ../port/timer/: timer.c
software components: CMSIS:CORE 4.3.0
